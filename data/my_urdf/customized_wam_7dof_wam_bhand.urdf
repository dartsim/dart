Commit message: change of offset of wam/wam_fixed_joint origin

File: data/my_urdf/customized_wam_7dof_wam_bhand.urdf (robot description, URDF)
Before this commit: robot wam, 24 links, 23 joints
Joints:
- joint wam/wam_fixed_joint: origin xyz=0.02 0.46 1 rpy=0 0 0 -> xyz=0.0 0.0 0.0 rpy=0 0 0
